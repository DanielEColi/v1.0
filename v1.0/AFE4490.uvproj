# Keil uVision project AFE4490.uvproj, settings and files
target AFE4490 (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: OneOXI-DM82 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: .\App;.\BSP;.\SpO2;.\STM32F2xx_StdPeriph_Driver;.\Usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./App/: main.c global.c stm32_dsp.h datatype.h global.h fir_stm32.s startup_stm32f2xx.s stm32f2xx_conf.h system_stm32f2xx.c system_stm32f2xx.h stm32f2xx.h iirarma_stm32.s strategy.c strategy.h fft.c test.lib
  group STM32F2xx_StdPeriph_Driver
    ./STM32F2xx_StdPeriph_Driver/: misc.c misc.h stm32f2xx_adc.c stm32f2xx_adc.h stm32f2xx_can.c stm32f2xx_can.h stm32f2xx_crc.c stm32f2xx_crc.h stm32f2xx_cryp.c stm32f2xx_cryp.h stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dac.h stm32f2xx_dbgmcu.c stm32f2xx_dbgmcu.h stm32f2xx_dcmi.c stm32f2xx_dcmi.h stm32f2xx_dma.c stm32f2xx_dma.h stm32f2xx_exti.c stm32f2xx_exti.h stm32f2xx_flash.c stm32f2xx_flash.h stm32f2xx_fsmc.c stm32f2xx_fsmc.h stm32f2xx_gpio.c stm32f2xx_gpio.h stm32f2xx_hash.c stm32f2xx_hash.h stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_i2c.h stm32f2xx_it.c stm32f2xx_it.h stm32f2xx_iwdg.c stm32f2xx_iwdg.h stm32f2xx_pwr.c stm32f2xx_pwr.h stm32f2xx_rcc.c stm32f2xx_rcc.h stm32f2xx_rng.c stm32f2xx_rng.h stm32f2xx_rtc.c stm32f2xx_rtc.h stm32f2xx_sdio.c stm32f2xx_sdio.h stm32f2xx_spi.c stm32f2xx_spi.h stm32f2xx_syscfg.c stm32f2xx_syscfg.h stm32f2xx_tim.c stm32f2xx_tim.h stm32f2xx_usart.c stm32f2xx_usart.h stm32f2xx_wwdg.c stm32f2xx_wwdg.h
  group BSP
    ./BSP/: bsp.h bsp.c
  group SpO2
    ./SpO2/: afe4490.c afe4490.h intcoeff.h ledcurrent.c ledcurrent.h
  group Usart
    ./Usart/: uart.c uart.h
